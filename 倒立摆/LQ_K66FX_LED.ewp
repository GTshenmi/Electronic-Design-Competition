# IAR project LQ_K66FX_LED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: src\User; src\Project_Setting\Libs; src\Project_Setting\Startup; src\Project_Setting\Linker; src\Drive
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K66FX_LED.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Setting\Linker\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MK66xN2M_18.icf
  group App/InvertedPendulum
    src/User/: Inverted_pendulum.c Inverted_pendulum.h
  group App/MathLib/Control
    Library/Control/PID/: pid_ctrl.c pid_ctrl.h
  group App/MathLib/DataProcess
    Library/DataProcess/Normalize/: normalize.c normalize.h
  group App/MathLib/Filter
    Library/Filter/MedianFilter/: median_filter.c median_filter.h
  group App/PaperCount
    src/User/: papercount.c papercount.h
  group App/Task
    src/User/: task.c task.h
  group App/UI
    src/User/: ui.c ui.h
  group Driver/SysDriver
    src/Drive/: common.h MK60_ADC.c MK60_ADC.h MK60_CMT.c MK60_CMT.h MK60_DMA.c MK60_DMA.h MK60_FLASH.c MK60_FLASH.h MK60_FTM.c MK60_FTM.h MK60_GPIO.c MK60_GPIO.h MK60_GPIO_Cfg.h MK60_IIC.c MK60_IIC.h MK60_LPTMR.c MK60_LPTMR.h MK60_PIT.c MK60_PIT.h MK60_PLL.c MK60_PLL.h MK60_SYSTICK.c MK60_SYSTICK.h MK60_UART.c MK60_UART.h MK60_WDOG.c MK60_WDOG.h
  group Driver/UserDriver/BEEP
    src/User/: beep.c beep.h
  group Driver/UserDriver/FDC2214
    src/User/: FDC2214.c FDC2214.h
  group Driver/UserDriver/KEY
    src/User/: key.c key.h
  group Driver/UserDriver/LCD
    src/User/: lcd_driver.c lcd_driver.h
  group Driver/UserDriver/LED
    src/User/: LQ_LED.c LQ_LED.h
  group Driver/UserDriver/OLED
    src/User/: oled.c oled.h oled_font.c oled_font.h
  group Driver/UserDriver/RNG
    src/User/: rng.c rng.h
  group Driver/UserDriver/WLUART
    src/User/: wluart.c wluart.h
  group Project_Setting/Startup
    src/Project_Setting/Libs/: MK66F18.h
    src/Project_Setting/Startup/: start.c startup_MK66F18.s
  group User
    src/User/: include.h IRQ_Handler.c main.c
  group User/ADC
    src/User/: adc.c adc.h
  group User/ANO
    src/User/: ANO_DT.c ANO_DT.h
  group User/MATH
    src/User/: matrix.c matrix.h
  group User/Motor
    src/User/: motor.c motor.h motor_ctrl.c motor_ctrl.h
  group User/Steer
    src/User/: steer.c steer.h steer_ctrl.c steer_ctrl.h
  group User/TripodHead
    ./: tripodhead.c
    src/User/: tripodhead.h
