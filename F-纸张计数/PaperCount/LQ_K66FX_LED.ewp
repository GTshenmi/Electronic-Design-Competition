# IAR project LQ_K66FX_LED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: src\User; src\Project_Setting\Libs; src\Project_Setting\Startup; src\Project_Setting\Linker; src\Drive
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K66FX_LED.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Setting\Linker\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MK66xN2M_18.icf
  group Driver
    src/Drive/: common.h MK60_ADC.c MK60_ADC.h MK60_CMT.c MK60_CMT.h MK60_DMA.c MK60_DMA.h MK60_FLASH.c MK60_FLASH.h MK60_FTM.c MK60_FTM.h MK60_GPIO.c MK60_GPIO.h MK60_GPIO_Cfg.h MK60_IIC.c MK60_IIC.h MK60_LPTMR.c MK60_LPTMR.h MK60_PIT.c MK60_PIT.h MK60_PLL.c MK60_PLL.h MK60_SYSTICK.c MK60_SYSTICK.h MK60_UART.c MK60_UART.h MK60_WDOG.c MK60_WDOG.h
  group PIDValue
    src/User/: pid_value.c
  group Project_Setting/Startup
    src/Project_Setting/Libs/: MK66F18.h
    src/Project_Setting/Startup/: start.c startup_MK66F18.s
  group User
    src/User/: include.h IRQ_Handler.c main.c
  group User/ADC
    src/User/: adc.c adc.h
  group User/ANO
    src/User/: ANO_DT.c ANO_DT.h
  group User/APP
    src/User/: papercount.c papercount.h
  group User/BEEP
    src/User/: beep.c beep.h
  group User/FDC2214
    src/User/: FDC2214.c FDC2214.h
  group User/Filter
    src/User/: median_filter.c median_filter.h
  group User/KEY
    src/User/: key.c key.h
  group User/LCD
    src/User/: lcd_driver.c lcd_driver.h
  group User/LED
    src/User/: LQ_LED.c LQ_LED.h
  group User/MATH
    src/User/: matrix.c matrix.h
  group User/OLED
    src/User/: oled.c oled.h oled_font.c oled_font.h
  group User/RNG
    src/User/: rng.c rng.h
  group User/UI
    src/User/: ui.c ui.h
  group User/WLUART
    src/User/: wluart.c wluart.h
