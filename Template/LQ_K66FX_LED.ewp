# IAR project LQ_K66FX_LED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: src\User; src\Project_Setting\Libs; src\Project_Setting\Startup; src\Project_Setting\Linker; src\Drive
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K66FX_LED.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Setting\Linker\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MK66xN2M_18.icf
  group App/ADC
    src/User/: adc_app.c adc_app.h
  group App/ECGSensor
    src/User/: egcsensor.c egcsensor.h
  group App/InfSensor
    src/User/: infrared_sensor.c infrared_sensor.h
  group App/Init
    src/User/: init.c init.h
  group App/InvertedPendulum
    src/User/: Inverted_pendulum.c Inverted_pendulum.h
  group App/MathLib/Control
    src/User/: pid_ctrl.c pid_ctrl.h
  group App/MathLib/DataProcess
    src/User/: normalize.c normalize.h
  group App/MathLib/Filter
    src/User/: filter.c filter.h
  group App/MotorCtrl
    src/User/: motor_ctrl.c motor_ctrl.h
  group App/PaperCount
    src/User/: papercount.c papercount.h
  group App/SteerCtrl
    src/User/: steer_ctrl.c steer_ctrl.h
  group App/Task
    src/User/: task.c task.h
  group App/TempSensor
    src/User/: tempsensor.c tempsensor.h
  group App/TriHeadCtrl
    src/User/: triheadctrl.c triheadctrl.h
  group App/UI
    src/User/: ui.c ui.h
  group Driver/SysDriver
    src/Drive/: common.h MK60_ADC.c MK60_ADC.h MK60_CMT.c MK60_CMT.h MK60_DMA.c MK60_DMA.h MK60_FLASH.c MK60_FLASH.h MK60_FTM.c MK60_FTM.h MK60_GPIO.c MK60_GPIO.h MK60_GPIO_Cfg.h MK60_IIC.c MK60_IIC.h MK60_LPTMR.c MK60_LPTMR.h MK60_PIT.c MK60_PIT.h MK60_PLL.c MK60_PLL.h MK60_SPI.c MK60_SPI.h MK60_SYSTICK.c MK60_SYSTICK.h MK60_UART.c MK60_UART.h MK60_WDOG.c MK60_WDOG.h
  group Driver/UserDriver
    src/User/: usr_common.h
  group Driver/UserDriver/ADC
    src/User/: adc.c adc.h
  group Driver/UserDriver/ADS1292
    src/User/: ads1292_driver.c ads1292_driver.h ads1292_spi.c ads1292_spi.h
  group Driver/UserDriver/AMG8833
    src/User/: amg8833_driver.c amg8833_driver.h interpolation.c interpolation.h
  group Driver/UserDriver/BEEP
    src/User/: beep.c beep.h
  group Driver/UserDriver/FDC2214
    src/User/: FDC2214.c FDC2214.h
  group Driver/UserDriver/GPIO
    src/User/: gpio.c gpio.h
  group Driver/UserDriver/ICM10602
    src/User/: LQ_ICM20602.c LQ_ICM20602.h
  group Driver/UserDriver/KEY
    src/User/: key.c key.h
  group Driver/UserDriver/LCD
    src/User/: lcd_driver.c lcd_driver.h
  group Driver/UserDriver/LED
    src/User/: led.c led.h
  group Driver/UserDriver/LMT70
    src/User/: lmt70.c lmt70.h LUTThreshold01C.c LUTThreshold01C.h
  group Driver/UserDriver/Motor
    src/User/: motor.c motor.h
  group Driver/UserDriver/OLED
    src/User/: oled.c oled.h oled_font.c oled_font.h
  group Driver/UserDriver/PWM
    src/User/: pwm.c pwm.h
  group Driver/UserDriver/RNG
    src/User/: rng.c rng.h
  group Driver/UserDriver/Steer
    src/User/: steer.c steer.h
  group Driver/UserDriver/TripodHead
    src/User/: tripodhead.c tripodhead.h
  group Driver/UserDriver/UART
    src/User/: uart.c uart.h
  group Driver/UserDriver/WLUART
    src/User/: wluart.c wluart.h
  group Project_Setting/Startup
    src/Project_Setting/Libs/: MK66F18.h
    src/Project_Setting/Startup/: start.c startup_MK66F18.s
  group User
    src/User/: include.h IRQ_Handler.c main.c
  group User/ANO
    src/User/: ANO_DT.c ANO_DT.h
  group User/MATH
    src/User/: matrix.c matrix.h
